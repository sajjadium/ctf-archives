#include <stdio.h>

char flag[64] = "bctf{fake_flag}";
char upper[] = {
    '?',  '?',  '?', '?', '?', '?', '?', '?', '?', '\t', '\n', '\x0b', '\x0c',
    '\r', '?',  '?', '?', '?', '?', '?', '?', '?', '?',  '?',  '?',    '?',
    '?',  '?',  '?', '?', '?', '?', ' ', '!', '"', '#',  '$',  '%',    '&',
    '\'', '(',  ')', '*', '+', ',', '-', '.', '/', '0',  '1',  '2',    '3',
    '4',  '5',  '6', '7', '8', '9', ':', ';', '<', '=',  '>',  '?',    '@',
    'A',  'B',  'C', 'D', 'E', 'F', 'G', 'H', 'I', 'J',  'K',  'L',    'M',
    'N',  'O',  'P', 'Q', 'R', 'S', 'T', 'U', 'V', 'W',  'X',  'Y',    'Z',
    '[',  '\\', ']', '^', '_', '`', 'A', 'B', 'C', 'D',  'E',  'F',    'G',
    'H',  'I',  'J', 'K', 'L', 'M', 'N', 'O', 'P', 'Q',  'R',  'S',    'T',
    'U',  'V',  'W', 'X', 'Y', 'Z', '{', '|', '}', '~',
};
char lower[] = {
    '?',  '?',  '?', '?', '?', '?', '?', '?', '?', '\t', '\n', '\x0b', '\x0c',
    '\r', '?',  '?', '?', '?', '?', '?', '?', '?', '?',  '?',  '?',    '?',
    '?',  '?',  '?', '?', '?', '?', ' ', '!', '"', '#',  '$',  '%',    '&',
    '\'', '(',  ')', '*', '+', ',', '-', '.', '/', '0',  '1',  '2',    '3',
    '4',  '5',  '6', '7', '8', '9', ':', ';', '<', '=',  '>',  '?',    '@',
    'a',  'b',  'c', 'd', 'e', 'f', 'g', 'h', 'i', 'j',  'k',  'l',    'm',
    'n',  'o',  'p', 'q', 'r', 's', 't', 'u', 'v', 'w',  'x',  'y',    'z',
    '[',  '\\', ']', '^', '_', '`', 'a', 'b', 'c', 'd',  'e',  'f',    'g',
    'h',  'i',  'j', 'k', 'l', 'm', 'n', 'o', 'p', 'q',  'r',  's',    't',
    'u',  'v',  'w', 'x', 'y', 'z', '{', '|', '}', '~',
};

int main() {
  setvbuf(stdin, 0, 2, 0);
  setvbuf(stdout, 0, 2, 0);

  FILE *f = fopen("flag.txt", "r");
  if (f) {
    fgets(flag, sizeof(flag), f);
    fclose(f);
  }

  char input[256];

  while (1) {
    printf("> ");
    if (!fgets(input, sizeof(input), stdin)) {
      break;
    }
    for (int i = 0; i < sizeof(input) && input[i]; i++) {
      char c = input[i];
      if (i % 2) {
        printf("%c", upper[c]);
      } else {
        printf("%c", lower[c]);
      }
    }
    printf("\n");
  }
}
